#include"head.h"
main()
{
uint8 cnt2;

M_A_=0;
M_A=0;
M_B=0;
M_B_=0;
P1&=0XC0;
CLK=0;
LAT=1;
CO=1;
UART_init();
for(cnt2=0;cnt2<60;cnt2++)
{
uart_data[cnt2]=0;
}
L=0;
delay(100000);
L=1;
while(1)
{
if(comcnt<60000)
{
comcnt++;
}
else if(comcnt==60000)
{
comcnt++; 
combit=0;
send(5);
}
if(go1)//前进
{
zt();
delay(300);
f();
delay(600);
relax();
delay(1400);
}
if(go2)//后退
{
zt();
delay(300);
b();
delay(600);
relax();
delay(1400);
}

}
}