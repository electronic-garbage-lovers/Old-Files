# Keil uVision project MLX90640_TEST_MCU32.uvproj, settings and files
target MLX90640_TEST_MCU32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MLX90640_TEST_MCU32
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_xl.s main.c cpu.c IIC.c MLX90640.c MLX90640_ExFun.c
